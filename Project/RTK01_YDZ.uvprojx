# Keil uVision project RTK01_YDZ.uvprojx, settings and files
target RTK01_YDZ (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: RTK01_YDZ +hex
  AfterMake: fromelf.exe --bin -o./output/RTK01_YDZ.bin ./output/RTK01_YDZ.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\FATFS\src;..\HARDWARE\Cam_FIFO;..\HARDWARE\EXIT;..\HARDWARE\FILE_INI;..\HARDWARE\GPS;..\HARDWARE\LED;..\HARDWARE\MY_FIFO;..\HARDWARE\OLED;..\HARDWARE\OLED\I2C_OLED_MOTO;..\HARDWARE\OLED\OLED_BMP;..\HARDWARE\OLED\OLED_GUI_TXT;..\HARDWARE\OLED\OLED_GUI_TXT\W25QXX;..\HARDWARE\PLAY_DATA;..\HARDWARE\RTC;..\HARDWARE\SDIO;..\HARDWARE\SRAM_DATA;..\HARDWARE\RTC;..\HARDWARE\SDIO;..\HARDWARE\SRAM_DATA;..\HARDWARE\TXT;..\HARDWARE\USART1_DMA;..\IAP;..\IAP\STM32_CRC;..\IAP\STMFLASH;..\library_V3.5\CORE;..\library_V3.5\STM32F10x;..\library_V3.5\SYSTEM\delay;..\library_V3.5\SYSTEM\sys;..\library_V3.5\SYSTEM\usart;..\library_V3.5\STM32F10x_FWLib\inc;..\MALLOC;..\FATFS\exfuns;..\HARDWARE\TIME4;..\Copyright
  memory RVCT4: ROM 0x8008000 size 0x38000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Project
    ./: main.c
  group HARDWARE
    ../HARDWARE/Cam_FIFO/: Cam_FIFO.c
    ../HARDWARE/EXIT/: Exit.c
    ../HARDWARE/FILE_INI/: file_ini.c
    ../HARDWARE/GPS/: Gps.c GPS_DATE.c GPS_STA.c
    ../HARDWARE/LED/: Led.c
    ../HARDWARE/MY_FIFO/: MY_FIFO.C
    ../HARDWARE/PLAY_DATA/: PLAY_DATA.C
    ../HARDWARE/RTC/: Rtc.c
    ../HARDWARE/SDIO/: sdio_sdcard.c
    ../HARDWARE/SRAM_DATA/: SRAM_DATA.c
    ../HARDWARE/USART1_DMA/: USART1_DMA.c
    ../HARDWARE/TXT/: Txt.c
    ../HARDWARE/TIME4/: TIM4.c
  group MALLOC
    ../MALLOC/: Malloc.c
  group IAP
    ../IAP/: IAP_DATA.C IAP_EXE.C IAP_PLAY.C
    ../IAP/STMFLASH/: stmflash.c
    ../IAP/STM32_CRC/: STM32_CRC.c
  group OLED
    ../HARDWARE/OLED/I2C_OLED_MOTO/: M_data.c OLED.c Spi1.c
    ../HARDWARE/OLED/OLED_BMP/: OLED_BMP.c OLED_BMP_Font.c
    ../HARDWARE/OLED/OLED_GUI_TXT/: fontupd.c OLED_GUI.c OLED_TXT.c
    ../HARDWARE/OLED/OLED_GUI_TXT/W25QXX/: SPI.c W25QXX.c
  group CORE
    ../library_V3.5/CORE/: core_cm3.c startup_stm32f10x_hd.s
  group STM32F10X
    ../library_V3.5/STM32F10x/: stm32f10x_it.c system_stm32f10x.c
  group SYSTEM
    ../library_V3.5/SYSTEM/delay/: delay.c
    ../library_V3.5/SYSTEM/sys/: sys.c
    ../library_V3.5/SYSTEM/usart/: usart.c
  group Library
    ../library_V3.5/STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Copyright
    ../Copyright/: Copyright.c
  group FATFS
    ../FATFS/src/: diskio.c ff.c mycc936.c
    ../FATFS/exfuns/: exfuns.c
  group 方案及修正
    ../: 方案及修正.txt
